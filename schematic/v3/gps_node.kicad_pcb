# Repository ttnmapper/ttntrackernode (continued)

## KiCad design schematic/v1/gps_node.kicad_pcb

Parts:
C1: 10uF; C_1206
C2, C7, C8, C9, C10, C11, C12, C13, C17, C18, C20: 100nF; C_0805
C3, C5, C6, C19: 4.7uF; C_0805
C14, C15: 22pF; C_0805
C16: 1uF; C_0805
D1, D2, D3: D_Small; BAS70
D4, D5: D_Small; DB2J411
D6: LED_Small_ALT; LED_0805
D7, D8: LED; LED_0805
F1: Polyfuse; bourns polyfuse
IC1: MMA8452Q
IC2: MCP73831/2; SOT-23-5
J1: USB_OTG; Molex_Microusb
J2: AVR ICSP; Pin_Header_Straight_2x03_Pitch2.54mm
J3: LIPO_BAT; Pin_Header_Straight_1x02_Pitch2.54mm
J4: SOLAR; Pin_Header_Straight_1x02_Pitch2.54mm
J5: FW_UPDATE; Pin_Header_Straight_1x06_Pitch2.54mm
J6: SMA; SMA_BOARD_UPRIGHT
J7, J8, J9, J10: Mounting Hole; MountingHole_3.2mm_M3_ISO14580_Pad
J11: TEST Vbatt; Socket_Strip_Straight_1x01_Pitch2.54mm
J12: Test 3.3v; Socket_Strip_Straight_1x01_Pitch2.54mm
J13: Test Gnd; Socket_Strip_Straight_1x01_Pitch2.54mm
J14: UART RF; Pin_Header_Straight_1x03_Pitch2.54mm
J15: I2C GPS; Pin_Header_Straight_1x03_Pitch2.54mm
J16: UART GPS; Pin_Header_Straight_1x03_Pitch2.54mm
J17: GPIO_0; Pin_Header_Straight_1x02_Pitch2.54mm
J18: GPIO_1; Pin_Header_Straight_1x02_Pitch2.54mm
LED1: WS2812B; LED_WS2812B-PLCC4
R1, R2, R7, R10, R12, R22, R23, R26: 4.7k; R_0805
R3, R4: 220; R_0805
R5, R6, R8, R9: 22; R_0805
R11, R13, R18, R19: 0; R_0805
R14, R20, R21, R24: 470; R_0805
R15: 2k; R_0805
R16, R17: 100k; R_0805
R25: 10k; R_0805
SW1: SW_SP3T; DP3T_switch
SW2, SW3, SW4: RESET; SW_SPST_PTS645
U1: TLV71333PDBV; SOT-23-5
U2: ublox-cam-m8q-0
U3: ATMEGA32U4-AU; TQFP-44_10x10mm_Pitch0.8mm
U4: RN2483
Y1: 16MHz; QC3CA_16MHz

Connections:
+3V3: C3.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, D6.2 (A), IC1.1, IC1.14, J2.2, J5.2, J12.1, LED1.1, R7.1, R10.1, R12.1, R22.1, R23.1, R25.2, R26.1, U1.5 (OUT), U2.1 (VCC_IO), U2.8 (V_BCKP), U2.9 (VCC), U3.14 (VCC), U3.24 (AVCC), U3.34 (VCC), U3.44 (AVCC), U4.12 (VDD), U4.34 (VDD)
+BATT: C1.1, C2.1, IC2.3 (VBAT), J11.1, R11.1, R16.1, SW1.3, U1.1 (IN)
/ACC_INT1: R9.1, U3.28 ((ADC11/PCINT4)PB4)
/ACC_INT2: R8.1, U3.12 ((OC0A/OC1C/~RTS~/PCINT7)PB7)
/BAT_MEASURE: C20.1, R16.2, R17.1, U3.41 ((ADC0)PF0)
/BUTTON_1: R26.2, SW4.2 (B), U3.39 ((ADC4/TCK)PF4)
/I2C_GPS_SCL: IC1.4, J15.1, R10.2, U2.6 (SCL/SPI_CLK), U3.18 ((OC0B/SCL/INT0)PD0)
/I2C_GPS_SDA: IC1.6, J15.2, R12.2, U2.3 (SDA/SPI_CS_N), U3.19 ((SDA/INT1)PD1)
/IN_0: J17.1, R22.2, U3.37 ((ADC6/TDO)PF6)
/IN_1: J18.1, R23.2, U3.36 ((ADC7/TDI)PF7)
/LED_OUT: R14.2, U3.22 ((XCK1/~CTS~)PD5)
/MCU_PWSEL0_IN: R1.1, U3.27 ((T0/OC4D/ADC10)PD7)
/MCU_PWSEL11_IN: R2.1, U3.26 ((T1/~OC4D~/ADC9)PD6)
/MCU__OUT: D3.2 (A), U3.25 ((ICP2/ADC8)PD4)
/MISO: J2.1, U3.10 ((PDI/MOSI/PCINT2)PB2)
/MOSI: J2.4, U3.11 ((PDO/MISO/PCINT3)PB3)
/REG_ENABLE: D1.1 (K), D2.1 (K), D3.1 (K), U1.3 (EN)
/RESET: J2.5, R7.2, SW2.2 (B), SW3.2 (B), U3.13 (~RESET~)
/RGB_LED: LED1.4, U3.1 ((INT6/AIN0)PE6)
/RN_RESET: J5.1, R24.1, R25.1, U4.32 (/RESET)
/SCK: J2.3, U3.9 ((SCLK/PCINT1)PB1)
/UART_AT_TO_RN: J14.1, U3.21 ((TXD/INT3)PD3), U4.7 (UART_RX)
/UART_GPS_IN: J16.2, R3.1, U3.30 ((ADC13/OC1B/OC4B/PCINT13)PB6)
/UART_GPS_OUT: J16.1, R4.1, U3.29 ((ADC12/OC1A/~OC4B~/PCINT12)PB5)
/UART_RN_TO_AT: J14.2, U3.20 ((RXD/INT2)PD2), U4.6 (UART_TX)
/USBD+: R5.1, U3.4 (D+)
/USBD-: R6.1, U3.3 (D-)
/V_Charger: C19.1, D4.1 (K), D5.1 (K), IC2.4 (VDD), R20.1
/V_Solar: D4.2 (A), R13.1
/charge_status: D7.1 (K), D8.2 (A), IC2.1 (STAT), U3.40 ((ADC1)PF1)
unnamed: C14.1, U3.17 (XTAL1), Y1.1
unnamed: C15.1, U3.16 (XTAL2), Y1.2
unnamed: C16.1, U3.6 (UCAP)
unnamed: C17.1, U3.42 (AREF)
unnamed: C18.1, IC1.2
unnamed: D1.2 (A), R1.2, SW1.2
unnamed: D2.2 (A), R2.2, SW1.4
unnamed: D6.1 (K), R14.1
unnamed: D7.2 (A), R20.2
unnamed: D8.1 (K), R21.1
unnamed: F1.2, J1.1 (VBUS)
unnamed: IC1.9, R8.2
unnamed: IC1.11, R9.2
unnamed: IC2.5 (PROG), R15.1
unnamed: J1.2 (D-), R6.2
unnamed: J1.3 (D+), R5.2
unnamed: J3.1, R11.2
unnamed: J4.1, R13.2
unnamed: J5.4, U4.31 (TEST1)
unnamed: J5.5, U4.30 (TEST0)
unnamed: J6.1, R18.2, R19.2
unnamed: R3.2, U2.26 (RXD/SPI_MOSI)
unnamed: R4.2, U2.25 (TXD/SPI_MISO)
unnamed: R18.1, U4.25 (RFL)
unnamed: R19.1, U4.23 (RFH)
unnamed: R24.2, U3.31 ((OC3A/~OC4A~)PC6)
unnamed: U2.16 (RF_OUT), U2.17 (RF_IN)
VBUS: D5.2 (A), F1.1, U3.2 (UVCC), U3.7 (VBUS)

Notes on the sheet:
Design based on: https://www.sparkfun.com/products/12587 and the Sodaq One
Charging
Standby

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
Board: 2 copper layers, 48.0 x 75.0 mm, 84 parts (24 on the bottom side), 60 nets.

File schematic/gps_node_bom.csv:

Reference, Quantity, Value, Footprint, Datasheet, Manufacturer
C1 ,1,"10uF","Capacitors_SMD:C_0805",""
C14 C15 ,2,"22pF","Capacitors_SMD:C_0805",""
C16 ,1,"1uF","Capacitors_SMD:C_0805",""
C19 ,1,"4.7uF","Capacitors_SMD:C_0805",""
C10 C11 C12 C13 C17 C18 C2 C20 C7 C8 C9 ,11,"100nF","Capacitors_SMD:C_0805",""
C3 C5 C6 ,3,"4.7u","Capacitors_SMD:C_0805",""
D1 D2 D3 D4 D5 ,5,"D_Small","",""
D6 ,1,"LED_Small_ALT","LEDs:LED_0805",""
D7 D8 ,2,"LED","LEDs:LED_0805",""
F1 ,1,"Polyfuse","",""
IC1 ,1,"MMA8452Q","",""
IC2 ,1,"MCP73831/2","TO_SOT_Packages_SMD:SOT-23-5","","Microchip Technology"
J1 ,1,"USB_OTG","",""
J11 ,1,"TEST Vbatt","Socket_Strips:Socket_Strip_Straight_1x01_Pitch2.54mm",""
J12 ,1,"Test 3.3v","Socket_Strips:Socket_Strip_Straight_1x01_Pitch2.54mm",""
J13 ,1,"Test Gnd","Socket_Strips:Socket_Strip_Straight_1x01_Pitch2.54mm",""
J14 ,1,"UART RF","Pin_Headers:Pin_Header_Straight_1x03_Pitch2.54mm_SMD_Pin1Left",""
J15 ,1,"I2C GPS","Pin_Headers:Pin_Header_Straight_1x03_Pitch2.54mm_SMD_Pin1Left",""
J16 ,1,"UART GPS","Pin_Headers:Pin_Header_Straight_1x03_Pitch2.54mm_SMD_Pin1Left",""
J17 ,1,"GPIO_0","Pin_Headers:Pin_Header_Straight_1x02_Pitch2.54mm_SMD_Pin1Left",""
J18 ,1,"GPIO_1","Pin_Headers:Pin_Header_Straight_1x02_Pitch2.54mm_SMD_Pin1Left",""
J2 ,1,"AVR ICSP","",""
J3 ,1,"LIPO_BAT","",""
J4 ,1,"SOLAR","",""
J5 ,1,"FW_UPDATE","",""
J6 ,1,"SMA","Microwave:SMA",""
J10 J7 J8 J9 ,4,"Mounting Hole","Mounting_Holes:MountingHole_3.2mm_M3_ISO14580_Pad",""
R11 R13 R18 R19 ,4,"0","Resistors_SMD:R_0805",""
R14 R20 R21 ,3,"470","Resistors_SMD:R_0805",""
R15 ,1,"2k","Resistors_SMD:R_0805",""
R16 R17 ,2,"100k","Resistors_SMD:R_0805",""
R3 R4 ,2,"220","Resistors_SMD:R_0805",""
R5 R6 R8 R9 ,4,"22","Resistors_SMD:R_0805",""
R1 R10 R12 R2 R22 R23 R7 ,7,"4.7k","Resistors_SMD:R_0805",""
SW1 ,1,"SW_SP3T","Buttons_Switches_THT:SW_DIP_x2_W7.62mm_Slide",""
SW2 ,1,"RESET","",""
U1 ,1,"TLV71333PDBV","TO_SOT_Packages_SMD:SOT-23-5",""
U2 ,1,"ublox-cam-m8q-0","",""
U3 ,1,"ATMEGA32U4-AU","",""
U4 ,1,"RN2483","",""
Y1 ,1,"16MHz","",""

## KiCad design schematic/gps_node.kicad_pcb

Parts:
C1, C19: NFM21HC105R1C3D; C_FEEDTHROUGH_0805
C2: 10uF; C_1206
C3, C5, C6: 4.7uF; C_0805
C4, C7, C8, C9, C10, C11, C12, C13, C17, C20, C21: 100nF; C_0805
C14, C15: 22pF; C_0805
C16: 1uF; C_0805
C18: 10uF; C_0805
D1, D2: BAS K73; D_SOT-23_ANK
D3, D4: LED_Small_ALT; LED_0805
D5, D6: LED; LED_0805
F1: Polyfuse; bourns polyfuse
IC1: MCP73831/2; SOT-23-5
J1, J2, J3, J4: Mounting Hole; MountingHole_3.2mm_M3_ISO14580_Pad
J5: TEST Vbatt; Socket_Strip_Straight_1x01_Pitch2.54mm
J6: USB_OTG; Molex_Microusb
J7: Test 3.3v; Socket_Strip_Straight_1x01_Pitch2.54mm
J8: Test Gnd; Socket_Strip_Straight_1x01_Pitch2.54mm
J9: Test V_bak; Socket_Strip_Straight_1x01_Pitch2.54mm
J11: AVR ICSP; Pin_Header_Straight_2x03_Pitch2.54mm
J12: UART RF; Pin_Header_Straight_1x03_Pitch2.54mm
J13: LIPO_BAT; Molex_PicoBlade_53047-0210_02x1.25mm_Straight
J14: SOLAR; Molex_PicoBlade_53047-0210_02x1.25mm_Straight
J15: UART GPS; Pin_Header_Straight_1x03_Pitch2.54mm
J16: FW_UPDATE; Pin_Header_Straight_1x06_Pitch2.54mm
J17: u.FL connector; CONN-RF-UFL
R1, R6, R10, R11: 10k; R_0805
R2, R3: 220; R_0805
R4, R5: 22; R_0805
R12, R13, R17, R18: 470; R_0805
R14: 2k; R_0805
R15, R16: 100k; R_0805
SW1: RS stock no. 448-0747; Pin_Header_Straight_1x03_Pitch2.54mm
SW2: RESET; SW_SPST_PTS645
SW3: MODE; SW_SPST_PTS645
U1, U3: TLV71333PDBV; SOT-23-5
U2: ublox-cam-m8q-0
U4: ATMEGA32U4-AU; TQFP-44_10x10mm_Pitch0.8mm
U5: RN2483
Y1: 16MHz; QC3CA_16MHz

Connections:
+3V3: C1.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C19.1, J7.1, J11.2, R6.1, R11.1, U1.5 (OUT), U4.14 (VCC), U4.24 (AVCC), U4.34 (VCC), U4.44 (AVCC)
+BATT: C2.1, C4.1, IC1.3 (VBAT), J5.1, J13.1, R15.1, SW1.2 (B), U1.1 (IN), U3.1 (IN), U3.3 (EN)
/BAT_MEASURE: C20.1, R15.2, R16.1, U4.41 ((ADC0)PF0)
/BUTTON_1: R11.2, SW3.2 (B), U4.18 ((OC0B/SCL/INT0)PD0)
/LED_OUT_GRN: R13.2, U4.36 ((ADC7/TDI)PF7)
/LED_OUT_RED: R12.2, U4.37 ((ADC6/TDO)PF6)
/MISO: J11.1, U4.11 ((PDO/MISO/PCINT3)PB3)
/MOSI: J11.4, U4.10 ((PDI/MOSI/PCINT2)PB2)
/REG_ENABLE: R1.1, SW1.3 (C), U1.3 (EN)
/RESET: J11.5, R6.2, SW2.2 (B), U4.13 (~RESET~)
/RN_RESET: J16.1, R10.1, U4.31 ((OC3A/~OC4A~)PC6), U5.32 (/RESET)
/SCK: J11.3, U4.9 ((SCLK/PCINT1)PB1)
/UART_AT_TO_RN: J12.1, U4.21 ((TXD/INT3)PD3), U5.7 (UART_RX)
/UART_GPS_IN: J15.2, R2.1, U4.30 ((ADC13/OC1B/OC4B/PCINT13)PB6)
/UART_GPS_OUT: J15.1, R3.1, U4.29 ((ADC12/OC1A/~OC4B~/PCINT12)PB5)
/UART_RN_TO_AT: J12.2, U4.20 ((RXD/INT2)PD2), U5.6 (UART_TX)
/USBD+: R4.1, U4.4 (D+)
/USBD-: R5.1, U4.3 (D-)
/V_Charger: C18.1, D1.1 (K), D2.1 (K), IC1.4 (VDD), R17.1
/V_RN: C5.1, C12.1, C19.3, J16.2, R10.2, U5.12 (VDD), U5.34 (VDD)
/V_Solar: D1.2 (A), J14.1
/V_bak: C21.1, J9.1, U2.8 (V_BCKP), U3.5 (OUT)
/charge_status: D5.1 (K), D6.2 (A), IC1.1 (STAT), U4.40 ((ADC1)PF1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, D3.1 (K), D4.1 (K), IC1.2 (VSS), J1.1, J2.1, J3.1, J4.1, J6.5 (GND), J6.6 (Shield), J8.1, J11.6, J12.3, J13.2, J14.2, J15.3, J16.3, J17.2 (Ext), R1.2, R14.2, R16.2, R18.2, SW2.1 (A), SW3.1 (A), U1.2 (GND), U2.4 (GND), U2.5 (GND), U2.10 (GND), U2.11 (GND), U2.12 (GND), U2.13 (GND), U2.14 (GND), U2.15 (GND), U2.18 (GND), U2.19 (GND), U2.21 (GND), U2.22 (GND), U2.27 (GND), U2.31 (GND), U3.2 (GND), U4.5 (UGND), U4.15 (GND), U4.23 (GND), U4.35 (GND), U4.43 (GND), U5.1 (GND), U5.8 (GND), U5.11 (GND), U5.20 (GND), U5.21 (GND), U5.22 (GND), U5.24 (GND), U5.26 (GND), U5.27 (GND), U5.28 (GND), U5.33 (GND), U5.41 (GND), U5.47 (GND)
unnamed: C1.3, C3.1, C13.1, U2.1 (VCC_IO), U2.9 (VCC)
unnamed: C14.1, U4.17 (XTAL1), Y1.1
unnamed: C15.1, U4.16 (XTAL2), Y1.2
unnamed: C16.1, U4.6 (UCAP)
unnamed: C17.1, U4.42 (AREF)
unnamed: D3.2 (A), R12.1
unnamed: D4.2 (A), R13.1
unnamed: D5.2 (A), R17.2
unnamed: D6.1 (K), R18.1
unnamed: F1.2, J6.1 (VBUS)
unnamed: IC1.5 (PROG), R14.1
unnamed: J6.2 (D-), R5.2
unnamed: J6.3 (D+), R4.2
unnamed: J16.4, U5.31 (TEST1)
unnamed: J16.5, U5.30 (TEST0)
unnamed: J17.1 (In), U5.23 (RFH)
unnamed: R2.2, U2.26 (RXD/SPI_MOSI)
unnamed: R3.2, U2.25 (TXD/SPI_MISO)
unnamed: U2.16 (RF_OUT), U2.17 (RF_IN)
VBUS: D2.2 (A), F1.1, U4.2 (UVCC), U4.7 (VBUS)

Notes on the sheet:
Design based on: https://www.sparkfun.com/products/12587 and the Sodaq One
Charging
Standby

Board: 2 copper layers, 48.0 x 75.0 mm, 69 parts (5 on the bottom side), 44 nets.

## Commit log (part)

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2017-12-09 Add gps module
2017-12-09 Add accelerometer
2017-12-09 Add connector for battery and solar panel
2017-12-09 Connect accelerometer interrupts
2017-12-09 Add ICSP header
2017-12-10 Cleaned up schematic, change avrisp component
2017-12-10 Add status LEDs for charger
2017-12-10 Updates readme
2017-12-10 Updates libraries
2017-12-10 Moves schematic to own folder
2017-12-11 Moved readme to top level
2017-12-11 Changed battery measurement
2018-01-12 Updates to power segment
2018-01-13 Updated datasheet links
2018-01-13 Add test and debug points
2018-01-13 Fix capacitor
2018-01-13 Schematic updated
2018-01-23 Footprints almost done, starting pcb layout
2018-02-04 First round of layout done
2018-02-05 Issue #2: Adds RN2483 reset pin
2018-03-25 Adds RGB led, updates schematic
2018-03-28 Added more group pour aroudd gps, additional buttons
2018-07-28 Simplify schematic
2018-07-28 Start initial pcb layout
2018-07-29 PCB layout finsihed
2018-07-29 Forgot to save
2018-08-17 Clean up silkscreen
2018-08-17 Further silkscreen cleanup
2018-08-17 Fix miso/mosi
2018-08-19 Decrease islands
2018-08-19 Fixed minor silkscreen issues
2018-08-29 Adds manufactured gerbers
2018-10-14 Move v1 schematic to subfolder
2018-10-14 Add v2 schematic
2018-10-14 Add firmware for both versions
2018-10-25 Add course and speed - incorrectly
2018-11-07 Add design files for enclosure
2018-11-07 Adds schematic version 3
2018-11-07 Updated d3 schematic to multiple sheets
2018-11-07 Small cleanup
2018-11-08 Started PCB layout
2018-11-08 Started layout work
2018-11-09 More layout work
2018-11-09 More layout
2018-11-10 Adds Accelerometer, layout almost done
2018-11-11 Fixed battery connector, started bom
2018-11-11 Update BOM, so old components
2018-11-12 Moved usb connector
2018-11-15 Removed 4th led from sticker
2018-11-24 Add pdf of enclosure sketch
2018-11-24 Add diodes before on/off switch to power device from either USB or battery
2018-11-24 Add 4.7uF caps around battery charger
2018-11-24 Add feedthrough cap for accelerometer
2018-11-24 Change accelerometer power label
2018-11-24 Replace 10uF by 4.7uF and clean up power circuit
2018-11-24 Cleaned up schematic
2018-11-24 Updated symbols
2018-11-26 Updated layout to revised schematic, moved switch and usb
2018-11-26 Updated layout
2018-11-26 Update layout, updated drawings
2018-11-27 Updated BOM
2021-11-08 Update README.md
    https://forum.kicad.info/t/warning-avoid-all-links-to-kicad-pcb-org-use-kicad-org/31521
