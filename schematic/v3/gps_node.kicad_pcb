# Repository ttnmapper/ttntrackernode

File README.md:

# TTN Tracker

The TTN Tracker is a [Things Network](https://www.thethingsnetwork.org/) node with a gps, used to map out coverage on [TTN Mapper](https://ttnmapper.org/). The device is aimed at end users, but can also be reprogrammed by more advanced users.

Thisrepository contains the schematics used to create the device as well as any additional files and the firmware that was loaded on the device.

### Schematics
The schematics were created using [KiCad 4.0.7](http://kicad.org/)

# Datasheets

These are links to the datasheets of important components used in the design.

 * [ATMEGA32U4](http://ww1.microchip.com/downloads/en/DeviceDoc/Atmel-7766-8-bit-AVR-ATmega16U4-32U4_Datasheet.pdf)  - Main Microcontroller
 * [RN2483](http://ww1.microchip.com/downloads/en/DeviceDoc/50002346C.pdf) - LoRa Module
 * [UBlox Cam M8Q](https://www.u-blox.com/sites/default/files/CAM-M8-FW3_DataSheet_%28UBX-15031574%29.pdf) - GPS
 	[Alternate datasheet](https://www.u-blox.com/sites/default/files/CAM-M8-FW3_HardwareIntegrationManual_%28UBX-15030063%29.pdf)
 * [MMA8452Q](https://www.nxp.com/docs/en/data-sheet/MMA8452Q.pdf) - Accelerometer
 * [MCP73831](http://ww1.microchip.com/downloads/en/DeviceDoc/20001984g.pdf) - LiPo Battery Charge management
 * [TLV71333PDBV](http://www.ti.com/lit/ds/symlink/tlv713p.pdf) - 3.3v Regulator

## KiCad design schematic/v3/gps_node.kicad_pcb

File schematic/README.md:

# TTN Tracker

The TTN Tracker is a [Things Network](https://www.thethingsnetwork.org/) node with a gps, used to map out coverage on [TTN Mapper](https://ttnmapper.org/). The device is aimed at end users, but can also be reprogrammed by more advanced users.

Thisrepository contains the schematics used to create the device as well as any additional files and the firmware that was loaded on the device.

###Schematics
The schematics were created using [KiCad 4.0.7](http://kicad-pcb.org/)

# Datasheets

These are links to the datasheets of important components used in the design.

 * [ATMEGA32U4](http://www.atmel.com/Images/Atmel-7766-8-bit-AVR-ATmega16U4-32U4_Datasheet.pdf)  - Main Microcontroller
 * [RN2483](http://ww1.microchip.com/downloads/en/DeviceDoc/50002346C.pdf) - LoRa Module
 * [UBlox Cam M8Q](https://www.u-blox.com/sites/default/files/CAM-M8-FW3_DataSheet_%28UBX-15031574%29.pdf) - GPS
 * [MMA8452Q](https://www.nxp.com/docs/en/data-sheet/MMA8452Q.pdf) - Accelerometer
 * [MCP73831](http://ww1.microchip.com/downloads/en/DeviceDoc/20001984g.pdf) - LiPo Battery Charge management
 * [TLV71333PDBV](http://www.ti.com/lit/ds/symlink/tlv713p.pdf) - 3.3v Regulator

Parts:
J1, J2, J3, J4: Mounting Hole; MountingHole_3.2mm_M3_ISO14580_Pad
J5: TEST Vbatt; PinHeader_1x01_P2.54mm_Vertical
J7: Test 3.3v; PinHeader_1x01_P2.54mm_Vertical
J8: Test Gnd; PinHeader_1x01_P2.54mm_Vertical
J9: Test V_bak; PinHeader_1x01_P2.54mm_Vertical

Connections:
GND: J1.1, J2.1, J3.1, J4.1, J8.1; also elsewhere on the board
V_3.3: J7.1; also elsewhere on the board
V_BAK: J9.1; also elsewhere on the board
V_BATT: J5.1; also elsewhere on the board

Notes on the sheet:
Design based on: https://www.sparkfun.com/products/12587 and the Sodaq One
Global power labels
Power test pads
Mounting Holes

Parts:
C2, C18, C21, C30: 4.7uF; C_0805_2012Metric
C4, C22, C28, C29: 100nF; C_0805_2012Metric
D1, D5, D6: BAS K73; D_SOT-23_ANK
D2: LED_Dual_CCAA; LED_DUAL_1206; Digikey 492-1245-1-ND
IC1: MCP73831/2; SOT-23-5
J13: LIPO_BAT; PinHeader_1x02_P2.00mm_Vertical
R14: 2k; R_0805_2012Metric
R17, R18: 470; R_0805_2012Metric
SW1: Switch; EG1224_Switch
U1, U3: TLV71333PDBV; SOT-23-5

Connections:
/Microcontroller/CHARGE_STATUS: D2.1 (A1), D2.4 (K2), IC1.1 (STAT); also elsewhere on the board
/power/V3.3_SUPPLY: C4.1, SW1.3 (C), U1.1 (IN), U1.3 (EN)
/power/V_BAK_SUPPLY: C21.2, C22.1, D5.1 (K), D6.1 (K), SW1.2 (B), U3.1 (IN), U3.3 (EN)
/power/V_Charger: C18.1, D1.1 (K), IC1.4 (VDD), R17.1
GND: C2.2, C4.2, C18.2, C21.1, C22.2, C28.2, C29.2, C30.2, IC1.2 (VSS), J13.2, R14.2, R18.2, U1.2 (GND), U3.2 (GND); also elsewhere on the board
unnamed: D2.2 (A2), R18.1
unnamed: D2.3 (K1), R17.2
unnamed: IC1.5 (PROG), R14.1
V_3.3: C29.1, U1.5 (OUT); also elsewhere on the board
V_BAK: C28.1, C30.1, U3.5 (OUT); also elsewhere on the board
V_BATT: C2.1, D5.2 (A), IC1.3 (VBAT), J13.1; also elsewhere on the board
V_BUS: D1.2 (A), D6.2 (A); also elsewhere on the board

Notes on the sheet:
Charging
Standby
Voltage Regulators
Backup voltage for the GPS. Always connected
Main board voltage Enabled via switch
Battery Charger
Status LED pin can be Lo, Hi or High-Z
Battery input
Global power labels
Input 4.7uF cap for both voltage regulators
No output 4.7uF cap as all sub circuits have their own

Parts:
C6: 4.7uF; C_0805_2012Metric
C7, C8, C9, C10, C11, C17, C20: 100nF; C_0805_2012Metric
C14, C15: 22pF; C_0805_2012Metric
C16: 1uF; C_0805_2012Metric
D3, D4: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
F1: Polyfuse; bourns polyfuse
J6: USB_OTG; Molex_Microusb
J11: AVR ICSP; PinHeader_2x03_P2.54mm_Vertical
J12: UART RF; PinHeader_1x03_P2.54mm_Vertical
J15: UART GPS; PinHeader_1x03_P2.54mm_Vertical
R4, R5: 22; R_0805_2012Metric
R6, R11: 10k; R_0805_2012Metric
R12, R13: 1k; R_0805_2012Metric
R15, R16: 100k; R_0805_2012Metric
SW2, SW3: SW_Push; SW_SPST_PTS645
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TestPoint; test_pad
U4: ATMEGA32U4-AU; TQFP-44_10x10mm_P0.8mm
Y1: 16MHz; QC3CA_16MHz

Connections:
/Microcontroller/ACCEL_CS: U4.32 ((ICP3/CLK0/OC4A)PC7); also elsewhere on the board
/Microcontroller/ACCEL_INT: U4.19 ((SDA/INT1)PD1); also elsewhere on the board
/Microcontroller/BAT_MEASURE: C20.2, R15.2, R16.1, U4.41 ((ADC0)PF0)
/Microcontroller/BUTTON_1: R11.2, SW3.1, U4.18 ((OC0B/SCL/INT0)PD0)
/Microcontroller/CHARGE_STATUS: U4.40 ((ADC1)PF1); also elsewhere on the board
/Microcontroller/LED0: R12.1, U4.37 ((ADC6/TDO)PF6)
/Microcontroller/LED1: R13.1, U4.36 ((ADC7/TDI)PF7)
/Microcontroller/RESET: J11.5, R6.2, SW2.1, U4.13 (~RESET~)
/Microcontroller/RN_RESET: U4.31 ((OC3A/~OC4A~)PC6); also elsewhere on the board
/Microcontroller/SPI_CLK: J11.3, U4.9 ((SCLK/PCINT1)PB1); also elsewhere on the board
/Microcontroller/SPI_MISO: J11.1, U4.11 ((PDO/MISO/PCINT3)PB3); also elsewhere on the board
/Microcontroller/SPI_MOSI: J11.4, U4.10 ((PDI/MOSI/PCINT2)PB2); also elsewhere on the board
/Microcontroller/UART_GPS_IN: J15.2, U4.30 ((ADC13/OC1B/OC4B/PCINT13)PB6); also elsewhere on the board
/Microcontroller/UART_GPS_OUT: J15.1, U4.29 ((ADC12/OC1A/~OC4B~/PCINT12)PB5); also elsewhere on the board
/Microcontroller/UART_RN_IN: J12.1, U4.21 ((TXD/INT3)PD3); also elsewhere on the board
/Microcontroller/UART_RN_OUT: J12.2, U4.20 ((RXD/INT2)PD2); also elsewhere on the board
/Microcontroller/USBD+: R4.2, U4.4 (D+)
/Microcontroller/USBD-: R5.2, U4.3 (D-)
GND: C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C14.2, C15.2, C16.1, C17.1, C20.1, D3.1 (K), D4.1 (K), J6.5 (GND), J6.6 (Shield), J11.6, J12.3, J15.3, R16.2, SW2.2, SW3.2, U4.5 (UGND), U4.15 (GND), U4.23 (GND), U4.35 (GND), U4.43 (GND); also elsewhere on the board
unnamed: C14.1, U4.17 (XTAL1), Y1.1
unnamed: C15.1, U4.16 (XTAL2), Y1.2
unnamed: C16.2, U4.6 (UCAP)
unnamed: C17.2, U4.42 (AREF)
unnamed: D3.2 (A), R12.2
unnamed: D4.2 (A), R13.2
unnamed: F1.2, J6.1 (VBUS)
unnamed: J6.2 (D-), R5.1
unnamed: J6.3 (D+), R4.1
unnamed: TP1.1, U4.28 ((ADC11/PCINT4)PB4)
unnamed: TP2.1, U4.12 ((OC0A/OC1C/~RTS~/PCINT7)PB7)
unnamed: TP3.1, U4.25 ((ICP2/ADC8)PD4)
unnamed: TP4.1, U4.22 ((XCK1/~CTS~)PD5)
unnamed: TP5.1, U4.26 ((T1/~OC4D~/ADC9)PD6)
unnamed: TP6.1, U4.27 ((T0/OC4D/ADC10)PD7)
unnamed: TP7.1, U4.39 ((ADC4/TCK)PF4)
unnamed: TP8.1, U4.38 ((ADC5/TMS)PF5)
V_3.3: C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, J11.2, R6.1, R11.1, U4.14 (VCC), U4.24 (AVCC), U4.34 (VCC), U4.44 (AVCC); also elsewhere on the board
V_BATT: R15.1; also elsewhere on the board
V_BUS: F1.1, U4.2 (UVCC), U4.7 (VBUS); also elsewhere on the board

Notes on the sheet:
Global power labels
USB
Battery Measurement
Output LEDs
LED0 : GPS Lock LED1: Transmitting
Output Headers (Optional)
ICSP Header and Reset
User input button (Optional)
Decoupling Capacitors

Parts:
C1, C19: NFM21HC105R1C3D; C_FEEDTHROUGH_0805
C3, C5: 4.7uF; C_0805_2012Metric
C12, C13, C23, C24, C25: 100nF; C_0805_2012Metric
J16: FW_UPDATE; PinHeader_1x06_P2.54mm_Vertical
J17: u.FL connector; CONN-RF-UFL
R2, R3: 220; R_0805_2012Metric
R10: 10k; R_0805_2012Metric
U2: ublox-cam-m8q-0
U5: RN2483

Connections:
/Microcontroller/RN_RESET: J16.1, R10.2, U5.32 (/RESET); also elsewhere on the board
/Microcontroller/UART_GPS_IN: R2.2; also elsewhere on the board
/Microcontroller/UART_GPS_OUT: R3.1; also elsewhere on the board
/Microcontroller/UART_RN_IN: U5.7 (UART_RX); also elsewhere on the board
/Microcontroller/UART_RN_OUT: U5.6 (UART_TX); also elsewhere on the board
/Sheet5C378858/GPS_POWER: C1.3, C3.1, C13.1, C25.1, U2.1 (VCC_IO), U2.9 (VCC)
/Sheet5C378858/RN_PGC: J16.5, U5.30 (TEST0)
/Sheet5C378858/RN_PGD: J16.4, U5.31 (TEST1)
/Sheet5C378858/RN_POWER: C5.1, C12.1, C19.3, C23.1, C24.1, J16.2, R10.1, U5.12 (VDD), U5.34 (VDD)
GND: C1.2, C3.2, C5.2, C12.2, C13.2, C19.2, C23.2, C24.2, C25.2, J16.3, J17.2 (Ext), U2.4 (GND), U2.5 (GND), U2.10 (GND), U2.11 (GND), U2.12 (GND), U2.13 (GND), U2.14 (GND), U2.15 (GND), U2.18 (GND), U2.19 (GND), U2.21 (GND), U2.22 (GND), U2.27 (GND), U2.31 (GND), U5.1 (GND), U5.8 (GND), U5.11 (GND), U5.20 (GND), U5.21 (GND), U5.22 (GND), U5.24 (GND), U5.26 (GND), U5.27 (GND), U5.28 (GND), U5.33 (GND), U5.41 (GND), U5.47 (GND); also elsewhere on the board
unnamed: J17.1 (In), U5.23 (RFH)
unnamed: R2.1, U2.26 (RXD/SPI_MOSI)
unnamed: R3.2, U2.25 (TXD/SPI_MISO)
unnamed: U2.16 (RF_OUT), U2.17 (RF_IN)
V_3.3: C1.1, C19.1; also elsewhere on the board
V_BAK: U2.8 (V_BCKP); also elsewhere on the board

Notes on the sheet:
Global power labels
RN Module
GPS Module

Parts:
C26: 4.7uF; C_0805_2012Metric
C27: 100nF; C_0805_2012Metric
C31: C_Feedthrough; C_FEEDTHROUGH_0805
U6: LIS3DH; LGA-16_3x3mm_P0.5mm_LayoutBorder3x5y

Connections:
/Microcontroller/ACCEL_CS: U6.8 (SPI_CS); also elsewhere on the board
/Microcontroller/ACCEL_INT: U6.11 (INT1); also elsewhere on the board
/Microcontroller/SPI_CLK: U6.4 (SCL/SPC); also elsewhere on the board
/Microcontroller/SPI_MISO: U6.7 (SDO/SA0); also elsewhere on the board
/Microcontroller/SPI_MOSI: U6.6 (SDA/SDI); also elsewhere on the board
/accelerometer/ACCEL_POWER: C26.1, C27.1, C31.3, U6.1 (VDD_IO), U6.14 (VDD)
GND: C26.2, C27.2, C31.2, U6.5 (GND), U6.10 (RES), U6.12 (GND); also elsewhere on the board
V_3.3: C31.1; also elsewhere on the board

Notes on the sheet:
Global power labels

Board: 2 copper layers, 48.0 x 75.0 mm, 86 parts (20 on the bottom side), 55 nets.

File schematic/v3/gps_node_bom.csv:

Source:,C:\Users\Kolijn\Temp\ttntrackernode\schematic\v3\gps_node.sch,,,,,,,,,,
Date:,2018/11/27 15:08:40,,,,,,,,,,
Tool:,Eeschema (5.0.1)-3,,,,,,,,,,
Generator:,C:\Program Files\KiCad\bin\scripting\plugins/bom_csv_grouped_by_value_with_fp.py,,,,,,,,,,
Component Count:,86,,,,,,,,,,
Ref,Qnty,Value,Cmp name,Footprint,Description,Vendor,,Digikey,,RS,
"C4, C22, C29, C28, C20, C17, C7, C8, C9, C10, C11, C12, C23, C24, C13, C25, C27, ",17,100nF,C-Device,Capacitor_SMD:C_0805_2012Metric,,,,311-1361-1-ND ,0.16,,
"C14, C15, ",2,22pF,C,Capacitor_SMD:C_0805_2012Metric,Unpolarized capacitor,,,399-8036-1-ND ,0.14,,
"C16, ",1,1uF,C-Device,Capacitor_SMD:C_0805_2012Metric,,,,399-1284-1-ND,0.17,,
"C18, C21, C30, C2, C6, C5, C3, C26, ",8,4.7uF,C-Device,Capacitor_SMD:C_0805_2012Metric,,,,,,,
"C19, C1, ",2,NFM21HC105R1C3D,C_Feedthrough,gps_node_components:C_FEEDTHROUGH_0805,,,,490-11839-1-ND,0.47,,
"C31, ",1,C_Feedthrough,C_Feedthrough,gps_node_components:C_FEEDTHROUGH_0805,Feedthrough capacitor,,,490-11839-1-ND,0.47,,
"D1, D5, D6, ",3,BAS K73,D_Small,Diode_SMD:D_SOT-23_ANK,,,,,, 738-4822,0.56
"D2, ",1,LED_Dual_CCAA,LED_Dual_CCAA-led_dual_ccaa,dual_led:LED_DUAL_1206,,,,492-1245-1-ND,0.68,,
"D4, D3, ",2,LED,LED-Device,LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder,,,,475-1278-1-ND ,0.38,,
,,,,,,,,475-1410-1-ND ,0.36,,
"F1, ",1,Polyfuse,Polyfuse,gps_node_components:bourns polyfuse,,,,,, 647-8184,6.833
"IC1, ",1,MCP73831/2,MCP73831_2,Package_TO_SOT_SMD:SOT-23-5,,,,MCP73831T-2ACI/OTCT-ND ,0.58,,
"J1, J2, J3, J4, ",4,Mounting Hole,Conn_01x01,MountingHole:MountingHole_3.2mm_M3_ISO14580_Pad,,,DNP,,,,
"J5, ",1,TEST Vbatt,Conn_01x01,Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical,,,DNP,,,,
"J6, ",1,USB_OTG,USB_OTG,gps_node_components:Molex_Microusb,,,,WM1399CT-ND ,0.97,,
"J7, ",1,Test 3.3v,Conn_01x01,Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical,,,DNP,,,,
"J8, ",1,Test Gnd,Conn_01x01,Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical,,,DNP,,,,
"J9, ",1,Test V_bak,Conn_01x01,Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical,,,DNP,,,,
"J11, ",1,AVR ICSP,Conn_02x03_Odd_Even,Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical,,,DNP,,,,
"J12, ",1,UART RF,Conn_01x03,Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical,,,DNP,,,,
"J13, ",1,LIPO_BAT,Conn_01x02,Connector_PinHeader_2.00mm:PinHeader_1x02_P2.00mm_Vertical,,,,455-1704-ND,0.17,,
"J15, ",1,UART GPS,Conn_01x03,Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical,,,DNP,,,,
"J16, ",1,FW_UPDATE,Conn_01x06,Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical,,,DNP,,,,
"J17, ",1,u.FL connector,Conn_Coaxial,gps_node_components:CONN-RF-UFL,,,,,, 557-981,10.932
"R3, R2, ",2,220,R-Device,Resistor_SMD:R_0805_2012Metric,,,,311-220ARCT-ND ,0.1,,
"R4, R5, ",2,22,R-Device,Resistor_SMD:R_0805_2012Metric,,,,311-22.0CRCT-ND,0.1,,
"R6, R11, R10, ",3,10k,R-Device,Resistor_SMD:R_0805_2012Metric,,,,311-10KARCT-ND,0.1,,
"R13, R12, ",2,1k,R-Device,Resistor_SMD:R_0805_2012Metric,,,,311-1.0KARCT-ND,0.1,,
"R14, ",1,2k,R_Small,Resistor_SMD:R_0805_2012Metric,,,,311-2.0KARCT-ND,0.1,,
"R16, R15, ",2,100k,R-Device,Resistor_SMD:R_0805_2012Metric,,,,311-100KCRCT-ND ,0.1,,
"R18, R17, ",2,470,R,Resistor_SMD:R_0805_2012Metric,,,,311-470ARCT-ND ,0.1,,
"SW1, ",1,Switch,SW_SPDT,EG1224:EG1224_Switch,,,,EG2585-ND,0.77,,
"SW3, SW2, ",2,SW_Push,SW_Push-Switch,Button_Switch_SMD:SW_SPST_PTS645,,,DNP,,,,
"TP3, TP4, TP7, TP5, TP6, TP8, TP2, TP1, ",8,TestPoint,TestPoint-Connector,test_pad:test_pad,,,DNP,,,,
"U1, U3, ",2,TLV71333PDBV,TLV71333PDBV,Package_TO_SOT_SMD:SOT-23-5,,,,296-35591-1-ND,0.42,,
"U2, ",1,ublox-cam-m8q-0,ublox-cam-m8q-0,drawn_by_jpmeijers:ublox-cam-m8q-0,,,,672-1013-1-ND,35.15,,
"U4, ",1,ATMEGA32U4-AU,ATMEGA32U4-AU,Package_QFP:TQFP-44_10x10mm_P0.8mm,,,,ATMEGA32U4-AU-ND,4.12,,
"U5, ",1,RN2483,RN2483,drawn_by_jpmeijers:RN2483,,,,RN2483A-I/RM104-ND,13.18,,
"U6, ",1,LIS3DH,LIS3DH-STM-LISxxx,Package_LGA:LGA-16_3x3mm_P0.5mm_LayoutBorder3x5y,,,,497-10613-1-ND ,0.79,,
"Y1, ",1,16MHz,Crystal,gps_node_components:QC3CA_16MHz,,,,644-1178-1-ND,1.03,,
,,,,,,,,,,,
,4,Hex Standoffs M3 Nylon 5mm,,,,,,RPC1483-ND,0.65,,
,4,Mach Screw Pan slotted M3x0.5,,,,,,36-29341-ND,0.2,,
,1,Antenna,,https://za.rs-online.com/web/p/telemetry-antennas/7934363/,,,,,,,
,1,SMA Cable & Antenna,,https://www.robotics.org.za/UFL-SMA-868MHZ,,,,,,,
,1,Battery,,https://www.robotics.org.za/503562?search=battery,,,,,,,
